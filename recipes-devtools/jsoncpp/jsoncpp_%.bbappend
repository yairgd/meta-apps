
EXTRA_OECMAKE += "-DCMAKE_INSTALL_FULL_INCLUDEDIR=\"/usr/include/jsoncpp\" "
